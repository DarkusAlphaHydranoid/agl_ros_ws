# ...use neon acceleration
EXTRA_OECONF:append:aarch64 = " --enable-arm-neon=on"
