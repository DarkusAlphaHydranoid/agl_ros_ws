do_install:prepend() {
    mkdir -p ${D}/${nonarch_base_libdir}
}
