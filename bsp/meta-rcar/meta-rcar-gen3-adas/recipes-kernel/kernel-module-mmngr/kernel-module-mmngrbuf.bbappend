KERNEL_MODULE_AUTOLOAD += "mmngrbuf"
KERNEL_MODULE_PROBECONF += "mmngrbuf"
module_conf_mmngrbuf = ""

COMPATIBLE_MACHINE_eagle = "eagle"
COMPATIBLE_MACHINE_v3msk = "v3msk"
COMPATIBLE_MACHINE_condor = "condor"
COMPATIBLE_MACHINE_v3mzf = "v3mzf"
COMPATIBLE_MACHINE_v3hsk = "v3hsk"
