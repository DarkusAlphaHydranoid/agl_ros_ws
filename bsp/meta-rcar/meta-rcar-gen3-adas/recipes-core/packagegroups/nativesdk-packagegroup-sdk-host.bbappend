RDEPENDS:${PN} += " \
	nativesdk-cmake \
"
