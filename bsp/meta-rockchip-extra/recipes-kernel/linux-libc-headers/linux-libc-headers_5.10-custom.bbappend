# NanoPC-T6 support

SRC_URI:nanopct6 = " \
    git://github.com/friendlyarm/kernel-rockchip.git;protocol=https;nobranch=1;branch=nanopi5-v5.10.y_opt; \
"
SRCREV:nanopct6 = "83ad55ea02e284cb96b49df7eda89dc6797d9d9c"
