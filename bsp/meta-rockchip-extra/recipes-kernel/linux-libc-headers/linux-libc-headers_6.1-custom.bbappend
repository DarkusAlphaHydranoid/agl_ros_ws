# NanoPC-T6 support

SRC_URI:nanopct6 = " \
    git://github.com/friendlyarm/kernel-rockchip.git;protocol=https;nobranch=1;branch=nanopi6-v6.1.y; \
"
SRCREV:nanopct6 = "d71ee263033d23540b9225bfa42909dfba09216e"
